# Keil uVision project Proje.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proje
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c PINS.h DEEP_SLEEP.c DEEP_SLEEP.h LCD.c Nokia5110.h RADAR.c RADAR.h SysTick_INIT.c BMP280.c BMP280.h I2C.c I2C.h KEYPAD.c KEYPAD.h KEYPAD.s HCSR04.c HCSR04.h LED_BUZZER.h LED_BUZZER.c ADC.c ADC.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
